# Keil uVision project gc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD1602.h delay.c delay.h LCD1602.c main.c OneWire.c OneWire.h DS18B20.h DS18B20.c AT24C02.c AT24C02.h I2C.c I2C.h key.c key.h timer0.c timer0.h bz.c bz.h
