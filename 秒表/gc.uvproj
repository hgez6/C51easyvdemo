# Keil uVision project gc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c xs.h delay.c delay.h xs.c key.h key.c timer0.h timer0.c AT24C02.c AT24C02.h I2C.c I2C.h
